<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\smoke sensor\sm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ultra.ewp</path>
    </project>
    <batchBuild />
</workspace>
